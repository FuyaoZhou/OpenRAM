* Functional test stimulus file for 10ns period

* TT process corner
.include "/Users/fuyaozhou/OpenRAM/technology/scn4m_subm/models/nom/pmos.sp"
.include "/Users/fuyaozhou/OpenRAM/technology/scn4m_subm/models/nom/nmos.sp"
.include "/tmp/openram_fuyaozhou_42764_temp/sram.sp"

* Global Power Supplies
Vvdd vdd 0 1.0

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xscn4m_subm-spice-710-128x8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 vdd gnd scn4m_subm-spice-710-128x8

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f

* Important signals for debug
* bl:	xsram:xbank0:bl_0_0
* br:	xsram:xbank0:br_0_0
* s_en:	xsram:s_en
* q:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q
* qbar:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 11110100  to  address 1111101 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 01010011  to  address 0000000 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 11011011  to  address 1111101 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 11011011 from address 1111101 (from port 0) during cycle 5 (50ns - 60ns)
*	Writing 00100000  to  address 1111110 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 11011011 from address 1111101 (from port 0) during cycle 7 (70ns - 80ns)
*	Reading 11011011 from address 1111101 (from port 0) during cycle 8 (80ns - 90ns)
*	Writing 01111110  to  address 1111110 (from port 0) during cycle 9 (90ns - 100ns)
*	Writing 10100000  to  address 1111101 (from port 0) during cycle 10 (100ns - 110ns)
*	Writing 01000100  to  address 1111011 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 11000101  to  address 0000001 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 11000101 from address 0000001 (from port 0) during cycle 17 (170ns - 180ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 10100000 from address 1111101 (from port 0) during cycle 22 (220ns - 230ns)
*	Writing 01100001  to  address 1111101 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing 10100010  to  address 1111101 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 01111110 from address 1111110 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing 01001100  to  address 0000001 (from port 0) during cycle 29 (290ns - 300ns)
*	Writing 11000100  to  address 0000010 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing 11101110  to  address 1111101 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 01001100 from address 0000001 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 37 (370ns - 380ns)
*	Writing 01011110  to  address 0000001 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 01011110 from address 0000001 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 11101110 from address 1111101 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 01011110 from address 0000001 (from port 0) during cycle 43 (430ns - 440ns)
*	Writing 11100101  to  address 1111101 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 01011110 from address 0000001 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 01111110 from address 1111110 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 11100101 from address 1111101 (from port 0) during cycle 60 (600ns - 610ns)
*	Writing 10110111  to  address 1111110 (from port 0) during cycle 61 (610ns - 620ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 11100101 from address 1111101 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 11100101 from address 1111101 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 01011110 from address 0000001 (from port 0) during cycle 73 (730ns - 740ns)
*	Reading 10110111 from address 1111110 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 01010011 from address 0000000 (from port 0) during cycle 77 (770ns - 780ns)
*	Writing 10111001  to  address 0000011 (from port 0) during cycle 78 (780ns - 790ns)
*	Writing 10100101  to  address 0000001 (from port 0) during cycle 79 (790ns - 800ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 11000100 from address 0000010 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing 11001101  to  address 0000010 (from port 0) during cycle 86 (860ns - 870ns)
*	Writing 01001111  to  address 1111100 (from port 0) during cycle 87 (870ns - 880ns)
*	Writing 10011000  to  address 0000010 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 10110111 from address 1111110 (from port 0) during cycle 89 (890ns - 900ns)
*	Writing 10101101  to  address 0000000 (from port 0) during cycle 90 (900ns - 910ns)
*	Writing 10010110  to  address 1111100 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 10101101 from address 0000000 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 10011000 from address 0000010 (from port 0) during cycle 94 (940ns - 950ns)
*	Writing 00101100  to  address 0000000 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 10110111 from address 1111110 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 01000100 from address 1111011 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 00101100 from address 0000000 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 11100101 from address 1111101 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 10011000 from address 0000010 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 10010110 from address 1111100 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Writing 01100011  to  address 1111101 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Writing 00010010  to  address 1111110 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Writing 00000100  to  address 0000011 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Writing 00101110  to  address 1111011 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 00101110 from address 1111011 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 10010110 from address 1111100 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 00101100 from address 0000000 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 10010110 from address 1111100 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Reading 10011000 from address 0000010 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Reading 10100101 from address 0000001 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Writing 10110000  to  address 0000001 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 10011000 from address 0000010 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Reading 10011000 from address 0000010 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing 00110000  to  address 1111100 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 00000100 from address 0000011 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing 11000010  to  address 0000010 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 00101110 from address 1111011 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Writing 11001111  to  address 1111011 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 01100011 from address 1111101 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Writing 01001100  to  address 1111101 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Reading 01001100 from address 1111101 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 01011000  to  address 0000011 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 01001100 from address 1111101 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Writing 01001011  to  address 1111100 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 01001100 from address 1111101 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 00101100 from address 0000000 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Writing 11011111  to  address 1111101 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Reading 11011111 from address 1111101 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 00101100 from address 0000000 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 11000010 from address 0000010 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Writing 00110111  to  address 1111100 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing 01100011  to  address 0000000 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing 10000101  to  address 1111100 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 01100011 from address 0000000 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Reading 00010010 from address 1111110 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Reading 10110000 from address 0000001 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 11000111  to  address 0000010 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 01011000 from address 0000011 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Reading 11000111 from address 0000010 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Writing 10010111  to  address 0000010 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Reading 01100011 from address 0000000 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 1.0v 29.45n 1.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 1.0v 169.45n 1.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 1.0v 199.45n 1.0v 199.55n 1.0v 209.45n 1.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 1.0v 789.45n 1.0v 789.55n 1.0v 799.45n 1.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 1.0v 869.45n 1.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 1.0v 909.45n 1.0v 909.55n 1.0v 919.45n 1.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 1.0v 1719.45n 1.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 1.0v 1889.45n 1.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 1.0v 1919.45n 1.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 1.0v 1949.45n 1.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 1.0v 1969.45n 1.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 1.0v 1989.45n 1.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 1.0v 29.45n 1.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 1.0v 939.45n 1.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 1.0v 1219.45n 1.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 1.0v 1479.45n 1.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 1.0v 1719.45n 1.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 1.0v 1889.45n 1.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 1.0v 119.45n 1.0v 119.55n 1.0v 129.45n 1.0v 129.55n 1.0v 139.45n 1.0v 139.55n 1.0v 149.45n 1.0v 149.55n 1.0v 159.45n 1.0v 159.55n 1.0v 169.45n 1.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 1.0v 199.45n 1.0v 199.55n 1.0v 209.45n 1.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 1.0v 299.45n 1.0v 299.55n 1.0v 309.45n 1.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 0.0v 789.45n 0.0v 789.55n 1.0v 799.45n 1.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 1.0v 869.45n 1.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 1.0v 909.45n 1.0v 909.55n 1.0v 919.45n 1.0v 919.55n 1.0v 929.45n 1.0v 929.55n 1.0v 939.45n 1.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 1.0v 989.45n 1.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 1.0v 1029.45n 1.0v 1029.55n 1.0v 1039.45n 1.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 1.0v 1059.45n 1.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 1.0v 1109.45n 1.0v 1109.55n 1.0v 1119.45n 1.0v 1119.55n 1.0v 1129.45n 1.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 1.0v 1219.45n 1.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 1.0v 1919.45n 1.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 1.0v 1949.45n 1.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 1.0v 1969.45n 1.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 1.0v 1989.45n 1.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 1.0v 299.45n 1.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 1.0v 789.45n 1.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 1.0v 869.45n 1.0v 869.55n 1.0v 879.45n 1.0v 879.55n 1.0v 889.45n 1.0v 889.55n 1.0v 899.45n 1.0v 899.55n 1.0v 909.45n 1.0v 909.55n 1.0v 919.45n 1.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 1.0v 989.45n 1.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 1.0v 1029.45n 1.0v 1029.55n 1.0v 1039.45n 1.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 1.0v 1059.45n 1.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 1.0v 1219.45n 1.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 1.0v 1579.45n 1.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 1.0v 1599.45n 1.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 1.0v 1719.45n 1.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 1.0v 29.45n 1.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 1.0v 789.45n 1.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 1.0v 889.45n 1.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 1.0v 939.45n 1.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 1.0v 1309.45n 1.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 1.0v 1389.45n 1.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 1.0v 1409.45n 1.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 1.0v 1439.45n 1.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 1.0v 1459.45n 1.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 1.0v 1579.45n 1.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 1.0v 1599.45n 1.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 1.0v 789.45n 1.0v 789.55n 1.0v 799.45n 1.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 1.0v 909.45n 1.0v 909.55n 1.0v 919.45n 1.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 1.0v 989.45n 1.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 1.0v 1029.45n 1.0v 1029.55n 1.0v 1039.45n 1.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 1.0v 1059.45n 1.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 1.0v 1219.45n 1.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 1.0v 1309.45n 1.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 1.0v 1389.45n 1.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 1.0v 1409.45n 1.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 1.0v 1439.45n 1.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 1.0v 1459.45n 1.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 1.0v 1889.45n 1.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 1.0v 29.45n 1.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 1.0v 119.45n 1.0v 119.55n 1.0v 129.45n 1.0v 129.55n 1.0v 139.45n 1.0v 139.55n 1.0v 149.45n 1.0v 149.55n 1.0v 159.45n 1.0v 159.55n 1.0v 169.45n 1.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 1.0v 199.45n 1.0v 199.55n 1.0v 209.45n 1.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 1.0v 299.45n 1.0v 299.55n 1.0v 309.45n 1.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 1.0v 869.45n 1.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 1.0v 1479.45n 1.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 1.0v 1579.45n 1.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 1.0v 1599.45n 1.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 1.0v 1719.45n 1.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 1.0v 1889.45n 1.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 1.0v 109.45n 1.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 1.0v 169.45n 1.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 1.0v 199.45n 1.0v 199.55n 1.0v 209.45n 1.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 0.0v 239.45n 0.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 1.0v 309.45n 1.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 1.0v 789.45n 1.0v 789.55n 1.0v 799.45n 1.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 1.0v 869.45n 1.0v 869.55n 0.0v 879.45n 0.0v 879.55n 1.0v 889.45n 1.0v 889.55n 1.0v 899.45n 1.0v 899.55n 1.0v 909.45n 1.0v 909.55n 1.0v 919.45n 1.0v 919.55n 1.0v 929.45n 1.0v 929.55n 1.0v 939.45n 1.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 1.0v 1309.45n 1.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 1.0v 1389.45n 1.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 1.0v 1409.45n 1.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 1.0v 1479.45n 1.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 1.0v 1919.45n 1.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 1.0v 1949.45n 1.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 1.0v 1969.45n 1.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 1.0v 1989.45n 1.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 0.0v 99.45n 0.0v 99.55n 1.0v 109.45n 1.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 1.0v 169.45n 1.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 1.0v 299.45n 1.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 1.0v 389.45n 1.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 1.0v 439.45n 1.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 0.0v 729.45n 0.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 1.0v 789.45n 1.0v 789.55n 1.0v 799.45n 1.0v 799.55n 1.0v 809.45n 1.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 1.0v 1109.45n 1.0v 1109.55n 1.0v 1119.45n 1.0v 1119.55n 1.0v 1129.45n 1.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 1.0v 1309.45n 1.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 1.0v 1439.45n 1.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 1.0v 1459.45n 1.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 1.0v 1579.45n 1.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 1.0v 1919.45n 1.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 1.0v 1969.45n 1.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 1.0v 1989.45n 1.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 1.0v 69.45n 1.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 1.0v 99.45n 1.0v 99.55n 0.0v 109.45n 0.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 1.0v 309.45n 1.0v 309.55n 0.0v 319.45n 0.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 0.0v 369.45n 0.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 1.0v 429.45n 1.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 1.0v 619.45n 1.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 1.0v 789.45n 1.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 1.0v 869.45n 1.0v 869.55n 0.0v 879.45n 0.0v 879.55n 1.0v 889.45n 1.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 1.0v 1059.45n 1.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 1.0v 1109.45n 1.0v 1109.55n 1.0v 1119.45n 1.0v 1119.55n 1.0v 1129.45n 1.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 1.0v 1389.45n 1.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 1.0v 1409.45n 1.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 1.0v 1439.45n 1.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 1.0v 1479.45n 1.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 1.0v 1579.45n 1.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 1.0v 1599.45n 1.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 1.0v 1999.45n 1.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 1.0v 2039.45n 1.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 0.0v 369.45n 0.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 0.0v 629.45n 0.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 0.0v 369.45n 0.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 0.0v 629.45n 0.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 0.0v 369.45n 0.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 0.0v 629.45n 0.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 1.0v 19.45n 1.0v 19.55n 0.0v 29.45n 0.0v 29.55n 1.0v 39.45n 1.0v 39.55n 0.0v 49.45n 0.0v 49.55n 1.0v 59.45n 1.0v 59.55n 1.0v 69.45n 1.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 1.0v 99.45n 1.0v 99.55n 1.0v 109.45n 1.0v 109.55n 1.0v 119.45n 1.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 1.0v 239.45n 1.0v 239.55n 1.0v 249.45n 1.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 1.0v 319.45n 1.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 0.0v 369.45n 0.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 1.0v 449.45n 1.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 1.0v 569.45n 1.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 1.0v 609.45n 1.0v 609.55n 1.0v 619.45n 1.0v 619.55n 0.0v 629.45n 0.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 1.0v 759.45n 1.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 1.0v 879.45n 1.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 1.0v 929.45n 1.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 1.0v 1089.45n 1.0v 1089.55n 1.0v 1099.45n 1.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 1.0v 1139.45n 1.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 1.0v 1419.45n 1.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 1.0v 1519.45n 1.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 1.0v 1559.45n 1.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 1.0v 1669.45n 1.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 1.0v 1749.45n 1.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 1.0v 1859.45n 1.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 1.0v 1899.45n 1.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 0), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 1), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.0v 9.45n 1.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 1.0v 139.45n 1.0v 139.55n 1.0v 149.45n 1.0v 149.55n 1.0v 159.45n 1.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 1.0v 189.45n 1.0v 189.55n 0.0v 199.45n 0.0v 199.55n 1.0v 209.45n 1.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 0.0v 279.45n 0.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 1.0v 339.45n 1.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 1.0v 419.45n 1.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 0.0v 689.45n 0.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 1.0v 749.45n 1.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 1.0v 919.45n 1.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 1.0v 1039.45n 1.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 1.0v 1119.45n 1.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 1.0v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.0v 9.45n 1.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 1.0v 49.45n 1.0v 49.55n 1.0v 59.45n 1.0v 59.55n 0.0v 69.45n 0.0v 69.55n 1.0v 79.45n 1.0v 79.55n 1.0v 89.45n 1.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 1.0v 129.45n 1.0v 129.55n 1.0v 139.45n 1.0v 139.55n 1.0v 149.45n 1.0v 149.55n 1.0v 159.45n 1.0v 159.55n 0.0v 169.45n 0.0v 169.55n 1.0v 179.45n 1.0v 179.55n 1.0v 189.45n 1.0v 189.55n 1.0v 199.45n 1.0v 199.55n 1.0v 209.45n 1.0v 209.55n 1.0v 219.45n 1.0v 219.55n 1.0v 229.45n 1.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 1.0v 259.45n 1.0v 259.55n 1.0v 269.45n 1.0v 269.55n 1.0v 279.45n 1.0v 279.55n 1.0v 289.45n 1.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 1.0v 329.45n 1.0v 329.55n 1.0v 339.45n 1.0v 339.55n 1.0v 349.45n 1.0v 349.55n 1.0v 359.45n 1.0v 359.55n 1.0v 369.45n 1.0v 369.55n 1.0v 379.45n 1.0v 379.55n 0.0v 389.45n 0.0v 389.55n 1.0v 399.45n 1.0v 399.55n 1.0v 409.45n 1.0v 409.55n 1.0v 419.45n 1.0v 419.55n 1.0v 429.45n 1.0v 429.55n 1.0v 439.45n 1.0v 439.55n 0.0v 449.45n 0.0v 449.55n 1.0v 459.45n 1.0v 459.55n 1.0v 469.45n 1.0v 469.55n 1.0v 479.45n 1.0v 479.55n 1.0v 489.45n 1.0v 489.55n 1.0v 499.45n 1.0v 499.55n 1.0v 509.45n 1.0v 509.55n 1.0v 519.45n 1.0v 519.55n 1.0v 529.45n 1.0v 529.55n 1.0v 539.45n 1.0v 539.55n 1.0v 549.45n 1.0v 549.55n 1.0v 559.45n 1.0v 559.55n 1.0v 569.45n 1.0v 569.55n 1.0v 579.45n 1.0v 579.55n 1.0v 589.45n 1.0v 589.55n 1.0v 599.45n 1.0v 599.55n 1.0v 609.45n 1.0v 609.55n 0.0v 619.45n 0.0v 619.55n 1.0v 629.45n 1.0v 629.55n 1.0v 639.45n 1.0v 639.55n 1.0v 649.45n 1.0v 649.55n 1.0v 659.45n 1.0v 659.55n 1.0v 669.45n 1.0v 669.55n 1.0v 679.45n 1.0v 679.55n 1.0v 689.45n 1.0v 689.55n 1.0v 699.45n 1.0v 699.55n 1.0v 709.45n 1.0v 709.55n 1.0v 719.45n 1.0v 719.55n 1.0v 729.45n 1.0v 729.55n 1.0v 739.45n 1.0v 739.55n 1.0v 749.45n 1.0v 749.55n 1.0v 759.45n 1.0v 759.55n 1.0v 769.45n 1.0v 769.55n 1.0v 779.45n 1.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 1.0v 809.45n 1.0v 809.55n 1.0v 819.45n 1.0v 819.55n 1.0v 829.45n 1.0v 829.55n 1.0v 839.45n 1.0v 839.55n 1.0v 849.45n 1.0v 849.55n 1.0v 859.45n 1.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 1.0v 899.45n 1.0v 899.55n 0.0v 909.45n 0.0v 909.55n 1.0v 919.45n 1.0v 919.55n 0.0v 929.45n 0.0v 929.55n 1.0v 939.45n 1.0v 939.55n 1.0v 949.45n 1.0v 949.55n 1.0v 959.45n 1.0v 959.55n 1.0v 969.45n 1.0v 969.55n 1.0v 979.45n 1.0v 979.55n 0.0v 989.45n 0.0v 989.55n 1.0v 999.45n 1.0v 999.55n 1.0v 1009.45n 1.0v 1009.55n 1.0v 1019.45n 1.0v 1019.55n 1.0v 1029.45n 1.0v 1029.55n 1.0v 1039.45n 1.0v 1039.55n 1.0v 1049.45n 1.0v 1049.55n 1.0v 1059.45n 1.0v 1059.55n 1.0v 1069.45n 1.0v 1069.55n 1.0v 1079.45n 1.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 1.0v 1119.45n 1.0v 1119.55n 1.0v 1129.45n 1.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 1.0v 1149.45n 1.0v 1149.55n 1.0v 1159.45n 1.0v 1159.55n 1.0v 1169.45n 1.0v 1169.55n 1.0v 1179.45n 1.0v 1179.55n 1.0v 1189.45n 1.0v 1189.55n 1.0v 1199.45n 1.0v 1199.55n 1.0v 1209.45n 1.0v 1209.55n 1.0v 1219.45n 1.0v 1219.55n 1.0v 1229.45n 1.0v 1229.55n 1.0v 1239.45n 1.0v 1239.55n 1.0v 1249.45n 1.0v 1249.55n 1.0v 1259.45n 1.0v 1259.55n 1.0v 1269.45n 1.0v 1269.55n 1.0v 1279.45n 1.0v 1279.55n 1.0v 1289.45n 1.0v 1289.55n 1.0v 1299.45n 1.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 1.0v 1319.45n 1.0v 1319.55n 1.0v 1329.45n 1.0v 1329.55n 1.0v 1339.45n 1.0v 1339.55n 1.0v 1349.45n 1.0v 1349.55n 1.0v 1359.45n 1.0v 1359.55n 1.0v 1369.45n 1.0v 1369.55n 1.0v 1379.45n 1.0v 1379.55n 1.0v 1389.45n 1.0v 1389.55n 1.0v 1399.45n 1.0v 1399.55n 1.0v 1409.45n 1.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 1.0v 1429.45n 1.0v 1429.55n 1.0v 1439.45n 1.0v 1439.55n 1.0v 1449.45n 1.0v 1449.55n 1.0v 1459.45n 1.0v 1459.55n 1.0v 1469.45n 1.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 1.0v 1489.45n 1.0v 1489.55n 1.0v 1499.45n 1.0v 1499.55n 1.0v 1509.45n 1.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 1.0v 1529.45n 1.0v 1529.55n 1.0v 1539.45n 1.0v 1539.55n 1.0v 1549.45n 1.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 1.0v 1569.45n 1.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 1.0v 1589.45n 1.0v 1589.55n 1.0v 1599.45n 1.0v 1599.55n 1.0v 1609.45n 1.0v 1609.55n 1.0v 1619.45n 1.0v 1619.55n 1.0v 1629.45n 1.0v 1629.55n 1.0v 1639.45n 1.0v 1639.55n 1.0v 1649.45n 1.0v 1649.55n 1.0v 1659.45n 1.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 1.0v 1679.45n 1.0v 1679.55n 1.0v 1689.45n 1.0v 1689.55n 1.0v 1699.45n 1.0v 1699.55n 1.0v 1709.45n 1.0v 1709.55n 1.0v 1719.45n 1.0v 1719.55n 1.0v 1729.45n 1.0v 1729.55n 1.0v 1739.45n 1.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 1.0v 1759.45n 1.0v 1759.55n 1.0v 1769.45n 1.0v 1769.55n 1.0v 1779.45n 1.0v 1779.55n 1.0v 1789.45n 1.0v 1789.55n 1.0v 1799.45n 1.0v 1799.55n 1.0v 1809.45n 1.0v 1809.55n 1.0v 1819.45n 1.0v 1819.55n 1.0v 1829.45n 1.0v 1829.55n 1.0v 1839.45n 1.0v 1839.55n 1.0v 1849.45n 1.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 1.0v 1869.45n 1.0v 1869.55n 1.0v 1879.45n 1.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 1.0v 1909.45n 1.0v 1909.55n 1.0v 1919.45n 1.0v 1919.55n 1.0v 1929.45n 1.0v 1929.55n 1.0v 1939.45n 1.0v 1939.55n 1.0v 1949.45n 1.0v 1949.55n 1.0v 1959.45n 1.0v 1959.55n 1.0v 1969.45n 1.0v 1969.55n 1.0v 1979.45n 1.0v 1979.55n 1.0v 1989.45n 1.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 1.0v 2009.45n 1.0v 2009.55n 1.0v 2019.45n 1.0v 2019.55n 1.0v 2029.45n 1.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 1.0v 2049.45n 1.0v 2049.55n 1.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.0 9.95n 0.1n 0.1n 4.9n 10n)

 * Generation of dout measurements
* CHECK dout0_0 vdout0_0ck4 = 1.0 time = 50
* CHECK dout0_1 vdout0_1ck4 = 1.0 time = 50
* CHECK dout0_2 vdout0_2ck4 = 0 time = 50
* CHECK dout0_3 vdout0_3ck4 = 0 time = 50
* CHECK dout0_4 vdout0_4ck4 = 1.0 time = 50
* CHECK dout0_5 vdout0_5ck4 = 0 time = 50
* CHECK dout0_6 vdout0_6ck4 = 1.0 time = 50
* CHECK dout0_7 vdout0_7ck4 = 0 time = 50
* CHECK dout0_0 vdout0_0ck5 = 1.0 time = 60
* CHECK dout0_1 vdout0_1ck5 = 1.0 time = 60
* CHECK dout0_2 vdout0_2ck5 = 0 time = 60
* CHECK dout0_3 vdout0_3ck5 = 1.0 time = 60
* CHECK dout0_4 vdout0_4ck5 = 1.0 time = 60
* CHECK dout0_5 vdout0_5ck5 = 0 time = 60
* CHECK dout0_6 vdout0_6ck5 = 1.0 time = 60
* CHECK dout0_7 vdout0_7ck5 = 1.0 time = 60
* CHECK dout0_0 vdout0_0ck7 = 1.0 time = 80
* CHECK dout0_1 vdout0_1ck7 = 1.0 time = 80
* CHECK dout0_2 vdout0_2ck7 = 0 time = 80
* CHECK dout0_3 vdout0_3ck7 = 1.0 time = 80
* CHECK dout0_4 vdout0_4ck7 = 1.0 time = 80
* CHECK dout0_5 vdout0_5ck7 = 0 time = 80
* CHECK dout0_6 vdout0_6ck7 = 1.0 time = 80
* CHECK dout0_7 vdout0_7ck7 = 1.0 time = 80
* CHECK dout0_0 vdout0_0ck8 = 1.0 time = 90
* CHECK dout0_1 vdout0_1ck8 = 1.0 time = 90
* CHECK dout0_2 vdout0_2ck8 = 0 time = 90
* CHECK dout0_3 vdout0_3ck8 = 1.0 time = 90
* CHECK dout0_4 vdout0_4ck8 = 1.0 time = 90
* CHECK dout0_5 vdout0_5ck8 = 0 time = 90
* CHECK dout0_6 vdout0_6ck8 = 1.0 time = 90
* CHECK dout0_7 vdout0_7ck8 = 1.0 time = 90
* CHECK dout0_0 vdout0_0ck12 = 1.0 time = 130
* CHECK dout0_1 vdout0_1ck12 = 1.0 time = 130
* CHECK dout0_2 vdout0_2ck12 = 0 time = 130
* CHECK dout0_3 vdout0_3ck12 = 0 time = 130
* CHECK dout0_4 vdout0_4ck12 = 1.0 time = 130
* CHECK dout0_5 vdout0_5ck12 = 0 time = 130
* CHECK dout0_6 vdout0_6ck12 = 1.0 time = 130
* CHECK dout0_7 vdout0_7ck12 = 0 time = 130
* CHECK dout0_0 vdout0_0ck17 = 1.0 time = 180
* CHECK dout0_1 vdout0_1ck17 = 0 time = 180
* CHECK dout0_2 vdout0_2ck17 = 1.0 time = 180
* CHECK dout0_3 vdout0_3ck17 = 0 time = 180
* CHECK dout0_4 vdout0_4ck17 = 0 time = 180
* CHECK dout0_5 vdout0_5ck17 = 0 time = 180
* CHECK dout0_6 vdout0_6ck17 = 1.0 time = 180
* CHECK dout0_7 vdout0_7ck17 = 1.0 time = 180
* CHECK dout0_0 vdout0_0ck19 = 1.0 time = 200
* CHECK dout0_1 vdout0_1ck19 = 1.0 time = 200
* CHECK dout0_2 vdout0_2ck19 = 0 time = 200
* CHECK dout0_3 vdout0_3ck19 = 0 time = 200
* CHECK dout0_4 vdout0_4ck19 = 1.0 time = 200
* CHECK dout0_5 vdout0_5ck19 = 0 time = 200
* CHECK dout0_6 vdout0_6ck19 = 1.0 time = 200
* CHECK dout0_7 vdout0_7ck19 = 0 time = 200
* CHECK dout0_0 vdout0_0ck21 = 0 time = 220
* CHECK dout0_1 vdout0_1ck21 = 0 time = 220
* CHECK dout0_2 vdout0_2ck21 = 1.0 time = 220
* CHECK dout0_3 vdout0_3ck21 = 0 time = 220
* CHECK dout0_4 vdout0_4ck21 = 0 time = 220
* CHECK dout0_5 vdout0_5ck21 = 0 time = 220
* CHECK dout0_6 vdout0_6ck21 = 1.0 time = 220
* CHECK dout0_7 vdout0_7ck21 = 0 time = 220
* CHECK dout0_0 vdout0_0ck22 = 0 time = 230
* CHECK dout0_1 vdout0_1ck22 = 0 time = 230
* CHECK dout0_2 vdout0_2ck22 = 0 time = 230
* CHECK dout0_3 vdout0_3ck22 = 0 time = 230
* CHECK dout0_4 vdout0_4ck22 = 0 time = 230
* CHECK dout0_5 vdout0_5ck22 = 1.0 time = 230
* CHECK dout0_6 vdout0_6ck22 = 0 time = 230
* CHECK dout0_7 vdout0_7ck22 = 1.0 time = 230
* CHECK dout0_0 vdout0_0ck27 = 0 time = 280
* CHECK dout0_1 vdout0_1ck27 = 1.0 time = 280
* CHECK dout0_2 vdout0_2ck27 = 1.0 time = 280
* CHECK dout0_3 vdout0_3ck27 = 1.0 time = 280
* CHECK dout0_4 vdout0_4ck27 = 1.0 time = 280
* CHECK dout0_5 vdout0_5ck27 = 1.0 time = 280
* CHECK dout0_6 vdout0_6ck27 = 1.0 time = 280
* CHECK dout0_7 vdout0_7ck27 = 0 time = 280
* CHECK dout0_0 vdout0_0ck32 = 0 time = 330
* CHECK dout0_1 vdout0_1ck32 = 0 time = 330
* CHECK dout0_2 vdout0_2ck32 = 1.0 time = 330
* CHECK dout0_3 vdout0_3ck32 = 0 time = 330
* CHECK dout0_4 vdout0_4ck32 = 0 time = 330
* CHECK dout0_5 vdout0_5ck32 = 0 time = 330
* CHECK dout0_6 vdout0_6ck32 = 1.0 time = 330
* CHECK dout0_7 vdout0_7ck32 = 0 time = 330
* CHECK dout0_0 vdout0_0ck34 = 0 time = 350
* CHECK dout0_1 vdout0_1ck34 = 0 time = 350
* CHECK dout0_2 vdout0_2ck34 = 1.0 time = 350
* CHECK dout0_3 vdout0_3ck34 = 0 time = 350
* CHECK dout0_4 vdout0_4ck34 = 0 time = 350
* CHECK dout0_5 vdout0_5ck34 = 0 time = 350
* CHECK dout0_6 vdout0_6ck34 = 1.0 time = 350
* CHECK dout0_7 vdout0_7ck34 = 0 time = 350
* CHECK dout0_0 vdout0_0ck35 = 0 time = 360
* CHECK dout0_1 vdout0_1ck35 = 0 time = 360
* CHECK dout0_2 vdout0_2ck35 = 1.0 time = 360
* CHECK dout0_3 vdout0_3ck35 = 0 time = 360
* CHECK dout0_4 vdout0_4ck35 = 0 time = 360
* CHECK dout0_5 vdout0_5ck35 = 0 time = 360
* CHECK dout0_6 vdout0_6ck35 = 1.0 time = 360
* CHECK dout0_7 vdout0_7ck35 = 0 time = 360
* CHECK dout0_0 vdout0_0ck36 = 0 time = 370
* CHECK dout0_1 vdout0_1ck36 = 0 time = 370
* CHECK dout0_2 vdout0_2ck36 = 1.0 time = 370
* CHECK dout0_3 vdout0_3ck36 = 1.0 time = 370
* CHECK dout0_4 vdout0_4ck36 = 0 time = 370
* CHECK dout0_5 vdout0_5ck36 = 0 time = 370
* CHECK dout0_6 vdout0_6ck36 = 1.0 time = 370
* CHECK dout0_7 vdout0_7ck36 = 0 time = 370
* CHECK dout0_0 vdout0_0ck37 = 0 time = 380
* CHECK dout0_1 vdout0_1ck37 = 0 time = 380
* CHECK dout0_2 vdout0_2ck37 = 1.0 time = 380
* CHECK dout0_3 vdout0_3ck37 = 0 time = 380
* CHECK dout0_4 vdout0_4ck37 = 0 time = 380
* CHECK dout0_5 vdout0_5ck37 = 0 time = 380
* CHECK dout0_6 vdout0_6ck37 = 1.0 time = 380
* CHECK dout0_7 vdout0_7ck37 = 0 time = 380
* CHECK dout0_0 vdout0_0ck39 = 0 time = 400
* CHECK dout0_1 vdout0_1ck39 = 1.0 time = 400
* CHECK dout0_2 vdout0_2ck39 = 1.0 time = 400
* CHECK dout0_3 vdout0_3ck39 = 1.0 time = 400
* CHECK dout0_4 vdout0_4ck39 = 1.0 time = 400
* CHECK dout0_5 vdout0_5ck39 = 0 time = 400
* CHECK dout0_6 vdout0_6ck39 = 1.0 time = 400
* CHECK dout0_7 vdout0_7ck39 = 0 time = 400
* CHECK dout0_0 vdout0_0ck40 = 0 time = 410
* CHECK dout0_1 vdout0_1ck40 = 1.0 time = 410
* CHECK dout0_2 vdout0_2ck40 = 1.0 time = 410
* CHECK dout0_3 vdout0_3ck40 = 1.0 time = 410
* CHECK dout0_4 vdout0_4ck40 = 0 time = 410
* CHECK dout0_5 vdout0_5ck40 = 1.0 time = 410
* CHECK dout0_6 vdout0_6ck40 = 1.0 time = 410
* CHECK dout0_7 vdout0_7ck40 = 1.0 time = 410
* CHECK dout0_0 vdout0_0ck42 = 0 time = 430
* CHECK dout0_1 vdout0_1ck42 = 0 time = 430
* CHECK dout0_2 vdout0_2ck42 = 1.0 time = 430
* CHECK dout0_3 vdout0_3ck42 = 0 time = 430
* CHECK dout0_4 vdout0_4ck42 = 0 time = 430
* CHECK dout0_5 vdout0_5ck42 = 0 time = 430
* CHECK dout0_6 vdout0_6ck42 = 1.0 time = 430
* CHECK dout0_7 vdout0_7ck42 = 1.0 time = 430
* CHECK dout0_0 vdout0_0ck43 = 0 time = 440
* CHECK dout0_1 vdout0_1ck43 = 1.0 time = 440
* CHECK dout0_2 vdout0_2ck43 = 1.0 time = 440
* CHECK dout0_3 vdout0_3ck43 = 1.0 time = 440
* CHECK dout0_4 vdout0_4ck43 = 1.0 time = 440
* CHECK dout0_5 vdout0_5ck43 = 0 time = 440
* CHECK dout0_6 vdout0_6ck43 = 1.0 time = 440
* CHECK dout0_7 vdout0_7ck43 = 0 time = 440
* CHECK dout0_0 vdout0_0ck48 = 0 time = 490
* CHECK dout0_1 vdout0_1ck48 = 0 time = 490
* CHECK dout0_2 vdout0_2ck48 = 1.0 time = 490
* CHECK dout0_3 vdout0_3ck48 = 0 time = 490
* CHECK dout0_4 vdout0_4ck48 = 0 time = 490
* CHECK dout0_5 vdout0_5ck48 = 0 time = 490
* CHECK dout0_6 vdout0_6ck48 = 1.0 time = 490
* CHECK dout0_7 vdout0_7ck48 = 1.0 time = 490
* CHECK dout0_0 vdout0_0ck49 = 0 time = 500
* CHECK dout0_1 vdout0_1ck49 = 0 time = 500
* CHECK dout0_2 vdout0_2ck49 = 1.0 time = 500
* CHECK dout0_3 vdout0_3ck49 = 0 time = 500
* CHECK dout0_4 vdout0_4ck49 = 0 time = 500
* CHECK dout0_5 vdout0_5ck49 = 0 time = 500
* CHECK dout0_6 vdout0_6ck49 = 1.0 time = 500
* CHECK dout0_7 vdout0_7ck49 = 1.0 time = 500
* CHECK dout0_0 vdout0_0ck50 = 0 time = 510
* CHECK dout0_1 vdout0_1ck50 = 1.0 time = 510
* CHECK dout0_2 vdout0_2ck50 = 1.0 time = 510
* CHECK dout0_3 vdout0_3ck50 = 1.0 time = 510
* CHECK dout0_4 vdout0_4ck50 = 1.0 time = 510
* CHECK dout0_5 vdout0_5ck50 = 0 time = 510
* CHECK dout0_6 vdout0_6ck50 = 1.0 time = 510
* CHECK dout0_7 vdout0_7ck50 = 0 time = 510
* CHECK dout0_0 vdout0_0ck54 = 1.0 time = 550
* CHECK dout0_1 vdout0_1ck54 = 1.0 time = 550
* CHECK dout0_2 vdout0_2ck54 = 0 time = 550
* CHECK dout0_3 vdout0_3ck54 = 0 time = 550
* CHECK dout0_4 vdout0_4ck54 = 1.0 time = 550
* CHECK dout0_5 vdout0_5ck54 = 0 time = 550
* CHECK dout0_6 vdout0_6ck54 = 1.0 time = 550
* CHECK dout0_7 vdout0_7ck54 = 0 time = 550
* CHECK dout0_0 vdout0_0ck55 = 1.0 time = 560
* CHECK dout0_1 vdout0_1ck55 = 1.0 time = 560
* CHECK dout0_2 vdout0_2ck55 = 0 time = 560
* CHECK dout0_3 vdout0_3ck55 = 0 time = 560
* CHECK dout0_4 vdout0_4ck55 = 1.0 time = 560
* CHECK dout0_5 vdout0_5ck55 = 0 time = 560
* CHECK dout0_6 vdout0_6ck55 = 1.0 time = 560
* CHECK dout0_7 vdout0_7ck55 = 0 time = 560
* CHECK dout0_0 vdout0_0ck56 = 0 time = 570
* CHECK dout0_1 vdout0_1ck56 = 1.0 time = 570
* CHECK dout0_2 vdout0_2ck56 = 1.0 time = 570
* CHECK dout0_3 vdout0_3ck56 = 1.0 time = 570
* CHECK dout0_4 vdout0_4ck56 = 1.0 time = 570
* CHECK dout0_5 vdout0_5ck56 = 1.0 time = 570
* CHECK dout0_6 vdout0_6ck56 = 1.0 time = 570
* CHECK dout0_7 vdout0_7ck56 = 0 time = 570
* CHECK dout0_0 vdout0_0ck57 = 1.0 time = 580
* CHECK dout0_1 vdout0_1ck57 = 1.0 time = 580
* CHECK dout0_2 vdout0_2ck57 = 0 time = 580
* CHECK dout0_3 vdout0_3ck57 = 0 time = 580
* CHECK dout0_4 vdout0_4ck57 = 1.0 time = 580
* CHECK dout0_5 vdout0_5ck57 = 0 time = 580
* CHECK dout0_6 vdout0_6ck57 = 1.0 time = 580
* CHECK dout0_7 vdout0_7ck57 = 0 time = 580
* CHECK dout0_0 vdout0_0ck60 = 1.0 time = 610
* CHECK dout0_1 vdout0_1ck60 = 0 time = 610
* CHECK dout0_2 vdout0_2ck60 = 1.0 time = 610
* CHECK dout0_3 vdout0_3ck60 = 0 time = 610
* CHECK dout0_4 vdout0_4ck60 = 0 time = 610
* CHECK dout0_5 vdout0_5ck60 = 1.0 time = 610
* CHECK dout0_6 vdout0_6ck60 = 1.0 time = 610
* CHECK dout0_7 vdout0_7ck60 = 1.0 time = 610
* CHECK dout0_0 vdout0_0ck62 = 0 time = 630
* CHECK dout0_1 vdout0_1ck62 = 0 time = 630
* CHECK dout0_2 vdout0_2ck62 = 1.0 time = 630
* CHECK dout0_3 vdout0_3ck62 = 0 time = 630
* CHECK dout0_4 vdout0_4ck62 = 0 time = 630
* CHECK dout0_5 vdout0_5ck62 = 0 time = 630
* CHECK dout0_6 vdout0_6ck62 = 1.0 time = 630
* CHECK dout0_7 vdout0_7ck62 = 1.0 time = 630
* CHECK dout0_0 vdout0_0ck63 = 0 time = 640
* CHECK dout0_1 vdout0_1ck63 = 0 time = 640
* CHECK dout0_2 vdout0_2ck63 = 1.0 time = 640
* CHECK dout0_3 vdout0_3ck63 = 0 time = 640
* CHECK dout0_4 vdout0_4ck63 = 0 time = 640
* CHECK dout0_5 vdout0_5ck63 = 0 time = 640
* CHECK dout0_6 vdout0_6ck63 = 1.0 time = 640
* CHECK dout0_7 vdout0_7ck63 = 0 time = 640
* CHECK dout0_0 vdout0_0ck64 = 1.0 time = 650
* CHECK dout0_1 vdout0_1ck64 = 0 time = 650
* CHECK dout0_2 vdout0_2ck64 = 1.0 time = 650
* CHECK dout0_3 vdout0_3ck64 = 0 time = 650
* CHECK dout0_4 vdout0_4ck64 = 0 time = 650
* CHECK dout0_5 vdout0_5ck64 = 1.0 time = 650
* CHECK dout0_6 vdout0_6ck64 = 1.0 time = 650
* CHECK dout0_7 vdout0_7ck64 = 1.0 time = 650
* CHECK dout0_0 vdout0_0ck65 = 1.0 time = 660
* CHECK dout0_1 vdout0_1ck65 = 1.0 time = 660
* CHECK dout0_2 vdout0_2ck65 = 0 time = 660
* CHECK dout0_3 vdout0_3ck65 = 0 time = 660
* CHECK dout0_4 vdout0_4ck65 = 1.0 time = 660
* CHECK dout0_5 vdout0_5ck65 = 0 time = 660
* CHECK dout0_6 vdout0_6ck65 = 1.0 time = 660
* CHECK dout0_7 vdout0_7ck65 = 0 time = 660
* CHECK dout0_0 vdout0_0ck68 = 1.0 time = 690
* CHECK dout0_1 vdout0_1ck68 = 0 time = 690
* CHECK dout0_2 vdout0_2ck68 = 1.0 time = 690
* CHECK dout0_3 vdout0_3ck68 = 0 time = 690
* CHECK dout0_4 vdout0_4ck68 = 0 time = 690
* CHECK dout0_5 vdout0_5ck68 = 1.0 time = 690
* CHECK dout0_6 vdout0_6ck68 = 1.0 time = 690
* CHECK dout0_7 vdout0_7ck68 = 1.0 time = 690
* CHECK dout0_0 vdout0_0ck71 = 0 time = 720
* CHECK dout0_1 vdout0_1ck71 = 0 time = 720
* CHECK dout0_2 vdout0_2ck71 = 1.0 time = 720
* CHECK dout0_3 vdout0_3ck71 = 0 time = 720
* CHECK dout0_4 vdout0_4ck71 = 0 time = 720
* CHECK dout0_5 vdout0_5ck71 = 0 time = 720
* CHECK dout0_6 vdout0_6ck71 = 1.0 time = 720
* CHECK dout0_7 vdout0_7ck71 = 0 time = 720
* CHECK dout0_0 vdout0_0ck72 = 0 time = 730
* CHECK dout0_1 vdout0_1ck72 = 0 time = 730
* CHECK dout0_2 vdout0_2ck72 = 1.0 time = 730
* CHECK dout0_3 vdout0_3ck72 = 0 time = 730
* CHECK dout0_4 vdout0_4ck72 = 0 time = 730
* CHECK dout0_5 vdout0_5ck72 = 0 time = 730
* CHECK dout0_6 vdout0_6ck72 = 1.0 time = 730
* CHECK dout0_7 vdout0_7ck72 = 1.0 time = 730
* CHECK dout0_0 vdout0_0ck73 = 0 time = 740
* CHECK dout0_1 vdout0_1ck73 = 1.0 time = 740
* CHECK dout0_2 vdout0_2ck73 = 1.0 time = 740
* CHECK dout0_3 vdout0_3ck73 = 1.0 time = 740
* CHECK dout0_4 vdout0_4ck73 = 1.0 time = 740
* CHECK dout0_5 vdout0_5ck73 = 0 time = 740
* CHECK dout0_6 vdout0_6ck73 = 1.0 time = 740
* CHECK dout0_7 vdout0_7ck73 = 0 time = 740
* CHECK dout0_0 vdout0_0ck75 = 1.0 time = 760
* CHECK dout0_1 vdout0_1ck75 = 1.0 time = 760
* CHECK dout0_2 vdout0_2ck75 = 1.0 time = 760
* CHECK dout0_3 vdout0_3ck75 = 0 time = 760
* CHECK dout0_4 vdout0_4ck75 = 1.0 time = 760
* CHECK dout0_5 vdout0_5ck75 = 1.0 time = 760
* CHECK dout0_6 vdout0_6ck75 = 0 time = 760
* CHECK dout0_7 vdout0_7ck75 = 1.0 time = 760
* CHECK dout0_0 vdout0_0ck76 = 1.0 time = 770
* CHECK dout0_1 vdout0_1ck76 = 1.0 time = 770
* CHECK dout0_2 vdout0_2ck76 = 0 time = 770
* CHECK dout0_3 vdout0_3ck76 = 0 time = 770
* CHECK dout0_4 vdout0_4ck76 = 1.0 time = 770
* CHECK dout0_5 vdout0_5ck76 = 0 time = 770
* CHECK dout0_6 vdout0_6ck76 = 1.0 time = 770
* CHECK dout0_7 vdout0_7ck76 = 0 time = 770
* CHECK dout0_0 vdout0_0ck77 = 1.0 time = 780
* CHECK dout0_1 vdout0_1ck77 = 1.0 time = 780
* CHECK dout0_2 vdout0_2ck77 = 0 time = 780
* CHECK dout0_3 vdout0_3ck77 = 0 time = 780
* CHECK dout0_4 vdout0_4ck77 = 1.0 time = 780
* CHECK dout0_5 vdout0_5ck77 = 0 time = 780
* CHECK dout0_6 vdout0_6ck77 = 1.0 time = 780
* CHECK dout0_7 vdout0_7ck77 = 0 time = 780
* CHECK dout0_0 vdout0_0ck80 = 0 time = 810
* CHECK dout0_1 vdout0_1ck80 = 0 time = 810
* CHECK dout0_2 vdout0_2ck80 = 1.0 time = 810
* CHECK dout0_3 vdout0_3ck80 = 0 time = 810
* CHECK dout0_4 vdout0_4ck80 = 0 time = 810
* CHECK dout0_5 vdout0_5ck80 = 0 time = 810
* CHECK dout0_6 vdout0_6ck80 = 1.0 time = 810
* CHECK dout0_7 vdout0_7ck80 = 0 time = 810
* CHECK dout0_0 vdout0_0ck81 = 0 time = 820
* CHECK dout0_1 vdout0_1ck81 = 0 time = 820
* CHECK dout0_2 vdout0_2ck81 = 1.0 time = 820
* CHECK dout0_3 vdout0_3ck81 = 0 time = 820
* CHECK dout0_4 vdout0_4ck81 = 0 time = 820
* CHECK dout0_5 vdout0_5ck81 = 0 time = 820
* CHECK dout0_6 vdout0_6ck81 = 1.0 time = 820
* CHECK dout0_7 vdout0_7ck81 = 1.0 time = 820
* CHECK dout0_0 vdout0_0ck85 = 0 time = 860
* CHECK dout0_1 vdout0_1ck85 = 0 time = 860
* CHECK dout0_2 vdout0_2ck85 = 1.0 time = 860
* CHECK dout0_3 vdout0_3ck85 = 0 time = 860
* CHECK dout0_4 vdout0_4ck85 = 0 time = 860
* CHECK dout0_5 vdout0_5ck85 = 0 time = 860
* CHECK dout0_6 vdout0_6ck85 = 1.0 time = 860
* CHECK dout0_7 vdout0_7ck85 = 0 time = 860
* CHECK dout0_0 vdout0_0ck89 = 1.0 time = 900
* CHECK dout0_1 vdout0_1ck89 = 1.0 time = 900
* CHECK dout0_2 vdout0_2ck89 = 1.0 time = 900
* CHECK dout0_3 vdout0_3ck89 = 0 time = 900
* CHECK dout0_4 vdout0_4ck89 = 1.0 time = 900
* CHECK dout0_5 vdout0_5ck89 = 1.0 time = 900
* CHECK dout0_6 vdout0_6ck89 = 0 time = 900
* CHECK dout0_7 vdout0_7ck89 = 1.0 time = 900
* CHECK dout0_0 vdout0_0ck93 = 1.0 time = 940
* CHECK dout0_1 vdout0_1ck93 = 0 time = 940
* CHECK dout0_2 vdout0_2ck93 = 1.0 time = 940
* CHECK dout0_3 vdout0_3ck93 = 1.0 time = 940
* CHECK dout0_4 vdout0_4ck93 = 0 time = 940
* CHECK dout0_5 vdout0_5ck93 = 1.0 time = 940
* CHECK dout0_6 vdout0_6ck93 = 0 time = 940
* CHECK dout0_7 vdout0_7ck93 = 1.0 time = 940
* CHECK dout0_0 vdout0_0ck94 = 0 time = 950
* CHECK dout0_1 vdout0_1ck94 = 0 time = 950
* CHECK dout0_2 vdout0_2ck94 = 0 time = 950
* CHECK dout0_3 vdout0_3ck94 = 1.0 time = 950
* CHECK dout0_4 vdout0_4ck94 = 1.0 time = 950
* CHECK dout0_5 vdout0_5ck94 = 0 time = 950
* CHECK dout0_6 vdout0_6ck94 = 0 time = 950
* CHECK dout0_7 vdout0_7ck94 = 1.0 time = 950
* CHECK dout0_0 vdout0_0ck99 = 1.0 time = 1000
* CHECK dout0_1 vdout0_1ck99 = 1.0 time = 1000
* CHECK dout0_2 vdout0_2ck99 = 1.0 time = 1000
* CHECK dout0_3 vdout0_3ck99 = 0 time = 1000
* CHECK dout0_4 vdout0_4ck99 = 1.0 time = 1000
* CHECK dout0_5 vdout0_5ck99 = 1.0 time = 1000
* CHECK dout0_6 vdout0_6ck99 = 0 time = 1000
* CHECK dout0_7 vdout0_7ck99 = 1.0 time = 1000
* CHECK dout0_0 vdout0_0ck101 = 0 time = 1020
* CHECK dout0_1 vdout0_1ck101 = 0 time = 1020
* CHECK dout0_2 vdout0_2ck101 = 1.0 time = 1020
* CHECK dout0_3 vdout0_3ck101 = 0 time = 1020
* CHECK dout0_4 vdout0_4ck101 = 0 time = 1020
* CHECK dout0_5 vdout0_5ck101 = 0 time = 1020
* CHECK dout0_6 vdout0_6ck101 = 1.0 time = 1020
* CHECK dout0_7 vdout0_7ck101 = 0 time = 1020
* CHECK dout0_0 vdout0_0ck102 = 0 time = 1030
* CHECK dout0_1 vdout0_1ck102 = 0 time = 1030
* CHECK dout0_2 vdout0_2ck102 = 1.0 time = 1030
* CHECK dout0_3 vdout0_3ck102 = 1.0 time = 1030
* CHECK dout0_4 vdout0_4ck102 = 0 time = 1030
* CHECK dout0_5 vdout0_5ck102 = 1.0 time = 1030
* CHECK dout0_6 vdout0_6ck102 = 0 time = 1030
* CHECK dout0_7 vdout0_7ck102 = 0 time = 1030
* CHECK dout0_0 vdout0_0ck104 = 1.0 time = 1050
* CHECK dout0_1 vdout0_1ck104 = 0 time = 1050
* CHECK dout0_2 vdout0_2ck104 = 1.0 time = 1050
* CHECK dout0_3 vdout0_3ck104 = 0 time = 1050
* CHECK dout0_4 vdout0_4ck104 = 0 time = 1050
* CHECK dout0_5 vdout0_5ck104 = 1.0 time = 1050
* CHECK dout0_6 vdout0_6ck104 = 1.0 time = 1050
* CHECK dout0_7 vdout0_7ck104 = 1.0 time = 1050
* CHECK dout0_0 vdout0_0ck105 = 0 time = 1060
* CHECK dout0_1 vdout0_1ck105 = 0 time = 1060
* CHECK dout0_2 vdout0_2ck105 = 0 time = 1060
* CHECK dout0_3 vdout0_3ck105 = 1.0 time = 1060
* CHECK dout0_4 vdout0_4ck105 = 1.0 time = 1060
* CHECK dout0_5 vdout0_5ck105 = 0 time = 1060
* CHECK dout0_6 vdout0_6ck105 = 0 time = 1060
* CHECK dout0_7 vdout0_7ck105 = 1.0 time = 1060
* CHECK dout0_0 vdout0_0ck107 = 0 time = 1080
* CHECK dout0_1 vdout0_1ck107 = 1.0 time = 1080
* CHECK dout0_2 vdout0_2ck107 = 1.0 time = 1080
* CHECK dout0_3 vdout0_3ck107 = 0 time = 1080
* CHECK dout0_4 vdout0_4ck107 = 1.0 time = 1080
* CHECK dout0_5 vdout0_5ck107 = 0 time = 1080
* CHECK dout0_6 vdout0_6ck107 = 0 time = 1080
* CHECK dout0_7 vdout0_7ck107 = 1.0 time = 1080
* CHECK dout0_0 vdout0_0ck112 = 0 time = 1130
* CHECK dout0_1 vdout0_1ck112 = 0 time = 1130
* CHECK dout0_2 vdout0_2ck112 = 1.0 time = 1130
* CHECK dout0_3 vdout0_3ck112 = 0 time = 1130
* CHECK dout0_4 vdout0_4ck112 = 0 time = 1130
* CHECK dout0_5 vdout0_5ck112 = 0 time = 1130
* CHECK dout0_6 vdout0_6ck112 = 0 time = 1130
* CHECK dout0_7 vdout0_7ck112 = 0 time = 1130
* CHECK dout0_0 vdout0_0ck116 = 0 time = 1170
* CHECK dout0_1 vdout0_1ck116 = 1.0 time = 1170
* CHECK dout0_2 vdout0_2ck116 = 1.0 time = 1170
* CHECK dout0_3 vdout0_3ck116 = 1.0 time = 1170
* CHECK dout0_4 vdout0_4ck116 = 0 time = 1170
* CHECK dout0_5 vdout0_5ck116 = 1.0 time = 1170
* CHECK dout0_6 vdout0_6ck116 = 0 time = 1170
* CHECK dout0_7 vdout0_7ck116 = 0 time = 1170
* CHECK dout0_0 vdout0_0ck117 = 0 time = 1180
* CHECK dout0_1 vdout0_1ck117 = 0 time = 1180
* CHECK dout0_2 vdout0_2ck117 = 1.0 time = 1180
* CHECK dout0_3 vdout0_3ck117 = 0 time = 1180
* CHECK dout0_4 vdout0_4ck117 = 0 time = 1180
* CHECK dout0_5 vdout0_5ck117 = 0 time = 1180
* CHECK dout0_6 vdout0_6ck117 = 0 time = 1180
* CHECK dout0_7 vdout0_7ck117 = 0 time = 1180
* CHECK dout0_0 vdout0_0ck118 = 0 time = 1190
* CHECK dout0_1 vdout0_1ck118 = 0 time = 1190
* CHECK dout0_2 vdout0_2ck118 = 1.0 time = 1190
* CHECK dout0_3 vdout0_3ck118 = 0 time = 1190
* CHECK dout0_4 vdout0_4ck118 = 0 time = 1190
* CHECK dout0_5 vdout0_5ck118 = 0 time = 1190
* CHECK dout0_6 vdout0_6ck118 = 0 time = 1190
* CHECK dout0_7 vdout0_7ck118 = 0 time = 1190
* CHECK dout0_0 vdout0_0ck119 = 0 time = 1200
* CHECK dout0_1 vdout0_1ck119 = 1.0 time = 1200
* CHECK dout0_2 vdout0_2ck119 = 1.0 time = 1200
* CHECK dout0_3 vdout0_3ck119 = 0 time = 1200
* CHECK dout0_4 vdout0_4ck119 = 1.0 time = 1200
* CHECK dout0_5 vdout0_5ck119 = 0 time = 1200
* CHECK dout0_6 vdout0_6ck119 = 0 time = 1200
* CHECK dout0_7 vdout0_7ck119 = 1.0 time = 1200
* CHECK dout0_0 vdout0_0ck121 = 0 time = 1220
* CHECK dout0_1 vdout0_1ck121 = 0 time = 1220
* CHECK dout0_2 vdout0_2ck121 = 1.0 time = 1220
* CHECK dout0_3 vdout0_3ck121 = 1.0 time = 1220
* CHECK dout0_4 vdout0_4ck121 = 0 time = 1220
* CHECK dout0_5 vdout0_5ck121 = 1.0 time = 1220
* CHECK dout0_6 vdout0_6ck121 = 0 time = 1220
* CHECK dout0_7 vdout0_7ck121 = 0 time = 1220
* CHECK dout0_0 vdout0_0ck123 = 0 time = 1240
* CHECK dout0_1 vdout0_1ck123 = 1.0 time = 1240
* CHECK dout0_2 vdout0_2ck123 = 0 time = 1240
* CHECK dout0_3 vdout0_3ck123 = 0 time = 1240
* CHECK dout0_4 vdout0_4ck123 = 1.0 time = 1240
* CHECK dout0_5 vdout0_5ck123 = 0 time = 1240
* CHECK dout0_6 vdout0_6ck123 = 0 time = 1240
* CHECK dout0_7 vdout0_7ck123 = 0 time = 1240
* CHECK dout0_0 vdout0_0ck126 = 0 time = 1270
* CHECK dout0_1 vdout0_1ck126 = 1.0 time = 1270
* CHECK dout0_2 vdout0_2ck126 = 1.0 time = 1270
* CHECK dout0_3 vdout0_3ck126 = 0 time = 1270
* CHECK dout0_4 vdout0_4ck126 = 1.0 time = 1270
* CHECK dout0_5 vdout0_5ck126 = 0 time = 1270
* CHECK dout0_6 vdout0_6ck126 = 0 time = 1270
* CHECK dout0_7 vdout0_7ck126 = 1.0 time = 1270
* CHECK dout0_0 vdout0_0ck127 = 0 time = 1280
* CHECK dout0_1 vdout0_1ck127 = 0 time = 1280
* CHECK dout0_2 vdout0_2ck127 = 1.0 time = 1280
* CHECK dout0_3 vdout0_3ck127 = 0 time = 1280
* CHECK dout0_4 vdout0_4ck127 = 0 time = 1280
* CHECK dout0_5 vdout0_5ck127 = 0 time = 1280
* CHECK dout0_6 vdout0_6ck127 = 0 time = 1280
* CHECK dout0_7 vdout0_7ck127 = 0 time = 1280
* CHECK dout0_0 vdout0_0ck128 = 0 time = 1290
* CHECK dout0_1 vdout0_1ck128 = 0 time = 1290
* CHECK dout0_2 vdout0_2ck128 = 0 time = 1290
* CHECK dout0_3 vdout0_3ck128 = 1.0 time = 1290
* CHECK dout0_4 vdout0_4ck128 = 1.0 time = 1290
* CHECK dout0_5 vdout0_5ck128 = 0 time = 1290
* CHECK dout0_6 vdout0_6ck128 = 0 time = 1290
* CHECK dout0_7 vdout0_7ck128 = 1.0 time = 1290
* CHECK dout0_0 vdout0_0ck129 = 1.0 time = 1300
* CHECK dout0_1 vdout0_1ck129 = 0 time = 1300
* CHECK dout0_2 vdout0_2ck129 = 1.0 time = 1300
* CHECK dout0_3 vdout0_3ck129 = 0 time = 1300
* CHECK dout0_4 vdout0_4ck129 = 0 time = 1300
* CHECK dout0_5 vdout0_5ck129 = 1.0 time = 1300
* CHECK dout0_6 vdout0_6ck129 = 0 time = 1300
* CHECK dout0_7 vdout0_7ck129 = 1.0 time = 1300
* CHECK dout0_0 vdout0_0ck132 = 0 time = 1330
* CHECK dout0_1 vdout0_1ck132 = 0 time = 1330
* CHECK dout0_2 vdout0_2ck132 = 1.0 time = 1330
* CHECK dout0_3 vdout0_3ck132 = 0 time = 1330
* CHECK dout0_4 vdout0_4ck132 = 0 time = 1330
* CHECK dout0_5 vdout0_5ck132 = 0 time = 1330
* CHECK dout0_6 vdout0_6ck132 = 0 time = 1330
* CHECK dout0_7 vdout0_7ck132 = 0 time = 1330
* CHECK dout0_0 vdout0_0ck134 = 1.0 time = 1350
* CHECK dout0_1 vdout0_1ck134 = 1.0 time = 1350
* CHECK dout0_2 vdout0_2ck134 = 0 time = 1350
* CHECK dout0_3 vdout0_3ck134 = 0 time = 1350
* CHECK dout0_4 vdout0_4ck134 = 0 time = 1350
* CHECK dout0_5 vdout0_5ck134 = 1.0 time = 1350
* CHECK dout0_6 vdout0_6ck134 = 1.0 time = 1350
* CHECK dout0_7 vdout0_7ck134 = 0 time = 1350
* CHECK dout0_0 vdout0_0ck135 = 0 time = 1360
* CHECK dout0_1 vdout0_1ck135 = 0 time = 1360
* CHECK dout0_2 vdout0_2ck135 = 1.0 time = 1360
* CHECK dout0_3 vdout0_3ck135 = 0 time = 1360
* CHECK dout0_4 vdout0_4ck135 = 0 time = 1360
* CHECK dout0_5 vdout0_5ck135 = 0 time = 1360
* CHECK dout0_6 vdout0_6ck135 = 0 time = 1360
* CHECK dout0_7 vdout0_7ck135 = 0 time = 1360
* CHECK dout0_0 vdout0_0ck136 = 1.0 time = 1370
* CHECK dout0_1 vdout0_1ck136 = 1.0 time = 1370
* CHECK dout0_2 vdout0_2ck136 = 0 time = 1370
* CHECK dout0_3 vdout0_3ck136 = 0 time = 1370
* CHECK dout0_4 vdout0_4ck136 = 0 time = 1370
* CHECK dout0_5 vdout0_5ck136 = 1.0 time = 1370
* CHECK dout0_6 vdout0_6ck136 = 1.0 time = 1370
* CHECK dout0_7 vdout0_7ck136 = 0 time = 1370
* CHECK dout0_0 vdout0_0ck137 = 0 time = 1380
* CHECK dout0_1 vdout0_1ck137 = 1.0 time = 1380
* CHECK dout0_2 vdout0_2ck137 = 0 time = 1380
* CHECK dout0_3 vdout0_3ck137 = 0 time = 1380
* CHECK dout0_4 vdout0_4ck137 = 1.0 time = 1380
* CHECK dout0_5 vdout0_5ck137 = 0 time = 1380
* CHECK dout0_6 vdout0_6ck137 = 0 time = 1380
* CHECK dout0_7 vdout0_7ck137 = 0 time = 1380
* CHECK dout0_0 vdout0_0ck138 = 0 time = 1390
* CHECK dout0_1 vdout0_1ck138 = 0 time = 1390
* CHECK dout0_2 vdout0_2ck138 = 0 time = 1390
* CHECK dout0_3 vdout0_3ck138 = 1.0 time = 1390
* CHECK dout0_4 vdout0_4ck138 = 1.0 time = 1390
* CHECK dout0_5 vdout0_5ck138 = 0 time = 1390
* CHECK dout0_6 vdout0_6ck138 = 0 time = 1390
* CHECK dout0_7 vdout0_7ck138 = 1.0 time = 1390
* CHECK dout0_0 vdout0_0ck140 = 0 time = 1410
* CHECK dout0_1 vdout0_1ck140 = 0 time = 1410
* CHECK dout0_2 vdout0_2ck140 = 0 time = 1410
* CHECK dout0_3 vdout0_3ck140 = 1.0 time = 1410
* CHECK dout0_4 vdout0_4ck140 = 1.0 time = 1410
* CHECK dout0_5 vdout0_5ck140 = 0 time = 1410
* CHECK dout0_6 vdout0_6ck140 = 0 time = 1410
* CHECK dout0_7 vdout0_7ck140 = 1.0 time = 1410
* CHECK dout0_0 vdout0_0ck142 = 1.0 time = 1430
* CHECK dout0_1 vdout0_1ck142 = 1.0 time = 1430
* CHECK dout0_2 vdout0_2ck142 = 0 time = 1430
* CHECK dout0_3 vdout0_3ck142 = 0 time = 1430
* CHECK dout0_4 vdout0_4ck142 = 0 time = 1430
* CHECK dout0_5 vdout0_5ck142 = 1.0 time = 1430
* CHECK dout0_6 vdout0_6ck142 = 1.0 time = 1430
* CHECK dout0_7 vdout0_7ck142 = 0 time = 1430
* CHECK dout0_0 vdout0_0ck143 = 0 time = 1440
* CHECK dout0_1 vdout0_1ck143 = 0 time = 1440
* CHECK dout0_2 vdout0_2ck143 = 1.0 time = 1440
* CHECK dout0_3 vdout0_3ck143 = 0 time = 1440
* CHECK dout0_4 vdout0_4ck143 = 0 time = 1440
* CHECK dout0_5 vdout0_5ck143 = 0 time = 1440
* CHECK dout0_6 vdout0_6ck143 = 0 time = 1440
* CHECK dout0_7 vdout0_7ck143 = 0 time = 1440
* CHECK dout0_0 vdout0_0ck145 = 0 time = 1460
* CHECK dout0_1 vdout0_1ck145 = 0 time = 1460
* CHECK dout0_2 vdout0_2ck145 = 0 time = 1460
* CHECK dout0_3 vdout0_3ck145 = 0 time = 1460
* CHECK dout0_4 vdout0_4ck145 = 1.0 time = 1460
* CHECK dout0_5 vdout0_5ck145 = 1.0 time = 1460
* CHECK dout0_6 vdout0_6ck145 = 0 time = 1460
* CHECK dout0_7 vdout0_7ck145 = 1.0 time = 1460
* CHECK dout0_0 vdout0_0ck146 = 1.0 time = 1470
* CHECK dout0_1 vdout0_1ck146 = 1.0 time = 1470
* CHECK dout0_2 vdout0_2ck146 = 0 time = 1470
* CHECK dout0_3 vdout0_3ck146 = 0 time = 1470
* CHECK dout0_4 vdout0_4ck146 = 0 time = 1470
* CHECK dout0_5 vdout0_5ck146 = 1.0 time = 1470
* CHECK dout0_6 vdout0_6ck146 = 1.0 time = 1470
* CHECK dout0_7 vdout0_7ck146 = 0 time = 1470
* CHECK dout0_0 vdout0_0ck148 = 1.0 time = 1490
* CHECK dout0_1 vdout0_1ck148 = 1.0 time = 1490
* CHECK dout0_2 vdout0_2ck148 = 0 time = 1490
* CHECK dout0_3 vdout0_3ck148 = 0 time = 1490
* CHECK dout0_4 vdout0_4ck148 = 0 time = 1490
* CHECK dout0_5 vdout0_5ck148 = 1.0 time = 1490
* CHECK dout0_6 vdout0_6ck148 = 1.0 time = 1490
* CHECK dout0_7 vdout0_7ck148 = 0 time = 1490
* CHECK dout0_0 vdout0_0ck150 = 0 time = 1510
* CHECK dout0_1 vdout0_1ck150 = 1.0 time = 1510
* CHECK dout0_2 vdout0_2ck150 = 1.0 time = 1510
* CHECK dout0_3 vdout0_3ck150 = 1.0 time = 1510
* CHECK dout0_4 vdout0_4ck150 = 0 time = 1510
* CHECK dout0_5 vdout0_5ck150 = 1.0 time = 1510
* CHECK dout0_6 vdout0_6ck150 = 0 time = 1510
* CHECK dout0_7 vdout0_7ck150 = 0 time = 1510
* CHECK dout0_0 vdout0_0ck152 = 0 time = 1530
* CHECK dout0_1 vdout0_1ck152 = 1.0 time = 1530
* CHECK dout0_2 vdout0_2ck152 = 0 time = 1530
* CHECK dout0_3 vdout0_3ck152 = 0 time = 1530
* CHECK dout0_4 vdout0_4ck152 = 0 time = 1530
* CHECK dout0_5 vdout0_5ck152 = 0 time = 1530
* CHECK dout0_6 vdout0_6ck152 = 1.0 time = 1530
* CHECK dout0_7 vdout0_7ck152 = 1.0 time = 1530
* CHECK dout0_0 vdout0_0ck153 = 0 time = 1540
* CHECK dout0_1 vdout0_1ck153 = 1.0 time = 1540
* CHECK dout0_2 vdout0_2ck153 = 0 time = 1540
* CHECK dout0_3 vdout0_3ck153 = 0 time = 1540
* CHECK dout0_4 vdout0_4ck153 = 0 time = 1540
* CHECK dout0_5 vdout0_5ck153 = 0 time = 1540
* CHECK dout0_6 vdout0_6ck153 = 1.0 time = 1540
* CHECK dout0_7 vdout0_7ck153 = 1.0 time = 1540
* CHECK dout0_0 vdout0_0ck154 = 1.0 time = 1550
* CHECK dout0_1 vdout0_1ck154 = 1.0 time = 1550
* CHECK dout0_2 vdout0_2ck154 = 0 time = 1550
* CHECK dout0_3 vdout0_3ck154 = 0 time = 1550
* CHECK dout0_4 vdout0_4ck154 = 0 time = 1550
* CHECK dout0_5 vdout0_5ck154 = 1.0 time = 1550
* CHECK dout0_6 vdout0_6ck154 = 1.0 time = 1550
* CHECK dout0_7 vdout0_7ck154 = 0 time = 1550
* CHECK dout0_0 vdout0_0ck156 = 0 time = 1570
* CHECK dout0_1 vdout0_1ck156 = 0 time = 1570
* CHECK dout0_2 vdout0_2ck156 = 1.0 time = 1570
* CHECK dout0_3 vdout0_3ck156 = 1.0 time = 1570
* CHECK dout0_4 vdout0_4ck156 = 0 time = 1570
* CHECK dout0_5 vdout0_5ck156 = 0 time = 1570
* CHECK dout0_6 vdout0_6ck156 = 1.0 time = 1570
* CHECK dout0_7 vdout0_7ck156 = 0 time = 1570
* CHECK dout0_0 vdout0_0ck159 = 0 time = 1600
* CHECK dout0_1 vdout0_1ck159 = 1.0 time = 1600
* CHECK dout0_2 vdout0_2ck159 = 0 time = 1600
* CHECK dout0_3 vdout0_3ck159 = 0 time = 1600
* CHECK dout0_4 vdout0_4ck159 = 0 time = 1600
* CHECK dout0_5 vdout0_5ck159 = 0 time = 1600
* CHECK dout0_6 vdout0_6ck159 = 1.0 time = 1600
* CHECK dout0_7 vdout0_7ck159 = 1.0 time = 1600
* CHECK dout0_0 vdout0_0ck163 = 0 time = 1640
* CHECK dout0_1 vdout0_1ck163 = 0 time = 1640
* CHECK dout0_2 vdout0_2ck163 = 1.0 time = 1640
* CHECK dout0_3 vdout0_3ck163 = 1.0 time = 1640
* CHECK dout0_4 vdout0_4ck163 = 0 time = 1640
* CHECK dout0_5 vdout0_5ck163 = 0 time = 1640
* CHECK dout0_6 vdout0_6ck163 = 1.0 time = 1640
* CHECK dout0_7 vdout0_7ck163 = 0 time = 1640
* CHECK dout0_0 vdout0_0ck167 = 0 time = 1680
* CHECK dout0_1 vdout0_1ck167 = 0 time = 1680
* CHECK dout0_2 vdout0_2ck167 = 1.0 time = 1680
* CHECK dout0_3 vdout0_3ck167 = 1.0 time = 1680
* CHECK dout0_4 vdout0_4ck167 = 0 time = 1680
* CHECK dout0_5 vdout0_5ck167 = 0 time = 1680
* CHECK dout0_6 vdout0_6ck167 = 1.0 time = 1680
* CHECK dout0_7 vdout0_7ck167 = 0 time = 1680
* CHECK dout0_0 vdout0_0ck169 = 0 time = 1700
* CHECK dout0_1 vdout0_1ck169 = 1.0 time = 1700
* CHECK dout0_2 vdout0_2ck169 = 0 time = 1700
* CHECK dout0_3 vdout0_3ck169 = 0 time = 1700
* CHECK dout0_4 vdout0_4ck169 = 0 time = 1700
* CHECK dout0_5 vdout0_5ck169 = 0 time = 1700
* CHECK dout0_6 vdout0_6ck169 = 1.0 time = 1700
* CHECK dout0_7 vdout0_7ck169 = 1.0 time = 1700
* CHECK dout0_0 vdout0_0ck170 = 0 time = 1710
* CHECK dout0_1 vdout0_1ck170 = 0 time = 1710
* CHECK dout0_2 vdout0_2ck170 = 0 time = 1710
* CHECK dout0_3 vdout0_3ck170 = 0 time = 1710
* CHECK dout0_4 vdout0_4ck170 = 1.0 time = 1710
* CHECK dout0_5 vdout0_5ck170 = 1.0 time = 1710
* CHECK dout0_6 vdout0_6ck170 = 0 time = 1710
* CHECK dout0_7 vdout0_7ck170 = 1.0 time = 1710
* CHECK dout0_0 vdout0_0ck171 = 0 time = 1720
* CHECK dout0_1 vdout0_1ck171 = 0 time = 1720
* CHECK dout0_2 vdout0_2ck171 = 1.0 time = 1720
* CHECK dout0_3 vdout0_3ck171 = 1.0 time = 1720
* CHECK dout0_4 vdout0_4ck171 = 0 time = 1720
* CHECK dout0_5 vdout0_5ck171 = 1.0 time = 1720
* CHECK dout0_6 vdout0_6ck171 = 0 time = 1720
* CHECK dout0_7 vdout0_7ck171 = 0 time = 1720
* CHECK dout0_0 vdout0_0ck173 = 0 time = 1740
* CHECK dout0_1 vdout0_1ck173 = 0 time = 1740
* CHECK dout0_2 vdout0_2ck173 = 0 time = 1740
* CHECK dout0_3 vdout0_3ck173 = 0 time = 1740
* CHECK dout0_4 vdout0_4ck173 = 1.0 time = 1740
* CHECK dout0_5 vdout0_5ck173 = 1.0 time = 1740
* CHECK dout0_6 vdout0_6ck173 = 0 time = 1740
* CHECK dout0_7 vdout0_7ck173 = 1.0 time = 1740
* CHECK dout0_0 vdout0_0ck175 = 0 time = 1760
* CHECK dout0_1 vdout0_1ck175 = 1.0 time = 1760
* CHECK dout0_2 vdout0_2ck175 = 0 time = 1760
* CHECK dout0_3 vdout0_3ck175 = 0 time = 1760
* CHECK dout0_4 vdout0_4ck175 = 1.0 time = 1760
* CHECK dout0_5 vdout0_5ck175 = 0 time = 1760
* CHECK dout0_6 vdout0_6ck175 = 0 time = 1760
* CHECK dout0_7 vdout0_7ck175 = 0 time = 1760
* CHECK dout0_0 vdout0_0ck177 = 0 time = 1780
* CHECK dout0_1 vdout0_1ck177 = 1.0 time = 1780
* CHECK dout0_2 vdout0_2ck177 = 0 time = 1780
* CHECK dout0_3 vdout0_3ck177 = 0 time = 1780
* CHECK dout0_4 vdout0_4ck177 = 0 time = 1780
* CHECK dout0_5 vdout0_5ck177 = 0 time = 1780
* CHECK dout0_6 vdout0_6ck177 = 1.0 time = 1780
* CHECK dout0_7 vdout0_7ck177 = 1.0 time = 1780
* CHECK dout0_0 vdout0_0ck178 = 0 time = 1790
* CHECK dout0_1 vdout0_1ck178 = 1.0 time = 1790
* CHECK dout0_2 vdout0_2ck178 = 0 time = 1790
* CHECK dout0_3 vdout0_3ck178 = 0 time = 1790
* CHECK dout0_4 vdout0_4ck178 = 1.0 time = 1790
* CHECK dout0_5 vdout0_5ck178 = 0 time = 1790
* CHECK dout0_6 vdout0_6ck178 = 0 time = 1790
* CHECK dout0_7 vdout0_7ck178 = 0 time = 1790
* CHECK dout0_0 vdout0_0ck179 = 1.0 time = 1800
* CHECK dout0_1 vdout0_1ck179 = 1.0 time = 1800
* CHECK dout0_2 vdout0_2ck179 = 1.0 time = 1800
* CHECK dout0_3 vdout0_3ck179 = 1.0 time = 1800
* CHECK dout0_4 vdout0_4ck179 = 1.0 time = 1800
* CHECK dout0_5 vdout0_5ck179 = 0 time = 1800
* CHECK dout0_6 vdout0_6ck179 = 1.0 time = 1800
* CHECK dout0_7 vdout0_7ck179 = 1.0 time = 1800
* CHECK dout0_0 vdout0_0ck180 = 0 time = 1810
* CHECK dout0_1 vdout0_1ck180 = 0 time = 1810
* CHECK dout0_2 vdout0_2ck180 = 1.0 time = 1810
* CHECK dout0_3 vdout0_3ck180 = 1.0 time = 1810
* CHECK dout0_4 vdout0_4ck180 = 0 time = 1810
* CHECK dout0_5 vdout0_5ck180 = 1.0 time = 1810
* CHECK dout0_6 vdout0_6ck180 = 0 time = 1810
* CHECK dout0_7 vdout0_7ck180 = 0 time = 1810
* CHECK dout0_0 vdout0_0ck181 = 0 time = 1820
* CHECK dout0_1 vdout0_1ck181 = 0 time = 1820
* CHECK dout0_2 vdout0_2ck181 = 0 time = 1820
* CHECK dout0_3 vdout0_3ck181 = 0 time = 1820
* CHECK dout0_4 vdout0_4ck181 = 1.0 time = 1820
* CHECK dout0_5 vdout0_5ck181 = 1.0 time = 1820
* CHECK dout0_6 vdout0_6ck181 = 0 time = 1820
* CHECK dout0_7 vdout0_7ck181 = 1.0 time = 1820
* CHECK dout0_0 vdout0_0ck183 = 0 time = 1840
* CHECK dout0_1 vdout0_1ck183 = 1.0 time = 1840
* CHECK dout0_2 vdout0_2ck183 = 0 time = 1840
* CHECK dout0_3 vdout0_3ck183 = 0 time = 1840
* CHECK dout0_4 vdout0_4ck183 = 0 time = 1840
* CHECK dout0_5 vdout0_5ck183 = 0 time = 1840
* CHECK dout0_6 vdout0_6ck183 = 1.0 time = 1840
* CHECK dout0_7 vdout0_7ck183 = 1.0 time = 1840
* CHECK dout0_0 vdout0_0ck184 = 0 time = 1850
* CHECK dout0_1 vdout0_1ck184 = 1.0 time = 1850
* CHECK dout0_2 vdout0_2ck184 = 0 time = 1850
* CHECK dout0_3 vdout0_3ck184 = 0 time = 1850
* CHECK dout0_4 vdout0_4ck184 = 0 time = 1850
* CHECK dout0_5 vdout0_5ck184 = 0 time = 1850
* CHECK dout0_6 vdout0_6ck184 = 1.0 time = 1850
* CHECK dout0_7 vdout0_7ck184 = 1.0 time = 1850
* CHECK dout0_0 vdout0_0ck191 = 0 time = 1920
* CHECK dout0_1 vdout0_1ck191 = 0 time = 1920
* CHECK dout0_2 vdout0_2ck191 = 0 time = 1920
* CHECK dout0_3 vdout0_3ck191 = 0 time = 1920
* CHECK dout0_4 vdout0_4ck191 = 1.0 time = 1920
* CHECK dout0_5 vdout0_5ck191 = 1.0 time = 1920
* CHECK dout0_6 vdout0_6ck191 = 0 time = 1920
* CHECK dout0_7 vdout0_7ck191 = 1.0 time = 1920
* CHECK dout0_0 vdout0_0ck194 = 1.0 time = 1950
* CHECK dout0_1 vdout0_1ck194 = 1.0 time = 1950
* CHECK dout0_2 vdout0_2ck194 = 0 time = 1950
* CHECK dout0_3 vdout0_3ck194 = 0 time = 1950
* CHECK dout0_4 vdout0_4ck194 = 0 time = 1950
* CHECK dout0_5 vdout0_5ck194 = 1.0 time = 1950
* CHECK dout0_6 vdout0_6ck194 = 1.0 time = 1950
* CHECK dout0_7 vdout0_7ck194 = 0 time = 1950
* CHECK dout0_0 vdout0_0ck195 = 0 time = 1960
* CHECK dout0_1 vdout0_1ck195 = 1.0 time = 1960
* CHECK dout0_2 vdout0_2ck195 = 0 time = 1960
* CHECK dout0_3 vdout0_3ck195 = 0 time = 1960
* CHECK dout0_4 vdout0_4ck195 = 1.0 time = 1960
* CHECK dout0_5 vdout0_5ck195 = 0 time = 1960
* CHECK dout0_6 vdout0_6ck195 = 0 time = 1960
* CHECK dout0_7 vdout0_7ck195 = 0 time = 1960
* CHECK dout0_0 vdout0_0ck196 = 0 time = 1970
* CHECK dout0_1 vdout0_1ck196 = 0 time = 1970
* CHECK dout0_2 vdout0_2ck196 = 0 time = 1970
* CHECK dout0_3 vdout0_3ck196 = 0 time = 1970
* CHECK dout0_4 vdout0_4ck196 = 1.0 time = 1970
* CHECK dout0_5 vdout0_5ck196 = 1.0 time = 1970
* CHECK dout0_6 vdout0_6ck196 = 0 time = 1970
* CHECK dout0_7 vdout0_7ck196 = 1.0 time = 1970
* CHECK dout0_0 vdout0_0ck197 = 0 time = 1980
* CHECK dout0_1 vdout0_1ck197 = 1.0 time = 1980
* CHECK dout0_2 vdout0_2ck197 = 0 time = 1980
* CHECK dout0_3 vdout0_3ck197 = 0 time = 1980
* CHECK dout0_4 vdout0_4ck197 = 1.0 time = 1980
* CHECK dout0_5 vdout0_5ck197 = 0 time = 1980
* CHECK dout0_6 vdout0_6ck197 = 0 time = 1980
* CHECK dout0_7 vdout0_7ck197 = 0 time = 1980
* CHECK dout0_0 vdout0_0ck198 = 0 time = 1990
* CHECK dout0_1 vdout0_1ck198 = 0 time = 1990
* CHECK dout0_2 vdout0_2ck198 = 0 time = 1990
* CHECK dout0_3 vdout0_3ck198 = 0 time = 1990
* CHECK dout0_4 vdout0_4ck198 = 1.0 time = 1990
* CHECK dout0_5 vdout0_5ck198 = 1.0 time = 1990
* CHECK dout0_6 vdout0_6ck198 = 0 time = 1990
* CHECK dout0_7 vdout0_7ck198 = 1.0 time = 1990
* CHECK dout0_0 vdout0_0ck201 = 0 time = 2020
* CHECK dout0_1 vdout0_1ck201 = 0 time = 2020
* CHECK dout0_2 vdout0_2ck201 = 0 time = 2020
* CHECK dout0_3 vdout0_3ck201 = 1.0 time = 2020
* CHECK dout0_4 vdout0_4ck201 = 1.0 time = 2020
* CHECK dout0_5 vdout0_5ck201 = 0 time = 2020
* CHECK dout0_6 vdout0_6ck201 = 1.0 time = 2020
* CHECK dout0_7 vdout0_7ck201 = 0 time = 2020
* CHECK dout0_0 vdout0_0ck202 = 1.0 time = 2030
* CHECK dout0_1 vdout0_1ck202 = 1.0 time = 2030
* CHECK dout0_2 vdout0_2ck202 = 1.0 time = 2030
* CHECK dout0_3 vdout0_3ck202 = 0 time = 2030
* CHECK dout0_4 vdout0_4ck202 = 0 time = 2030
* CHECK dout0_5 vdout0_5ck202 = 0 time = 2030
* CHECK dout0_6 vdout0_6ck202 = 1.0 time = 2030
* CHECK dout0_7 vdout0_7ck202 = 1.0 time = 2030
* CHECK dout0_0 vdout0_0ck204 = 1.0 time = 2050
* CHECK dout0_1 vdout0_1ck204 = 1.0 time = 2050
* CHECK dout0_2 vdout0_2ck204 = 0 time = 2050
* CHECK dout0_3 vdout0_3ck204 = 0 time = 2050
* CHECK dout0_4 vdout0_4ck204 = 0 time = 2050
* CHECK dout0_5 vdout0_5ck204 = 1.0 time = 2050
* CHECK dout0_6 vdout0_6ck204 = 1.0 time = 2050
* CHECK dout0_7 vdout0_7ck204 = 0 time = 2050
.include /Users/fuyaozhou/OpenRAM/scn4m_subm-spice-710-128x8/functional_meas.sp
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
